# Keil uVision project [Project].IMU330_ArraY_AT.uvprojx, settings and files
target [Project].IMU330_ArraY_AT (6160000::V6.16::ARMCLANG)
  device: -AT32F435CMU7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.2.1
  cpu: IRAM(0x20000000,0x18000000) IROM(0x08000000,0xfc000000F0000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: imu_array330
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F435CMU7,USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\mylib\inc;..\..\ASM330LHHX\inc;..\..\calibration\include;..\..\adxl375\inc;..\..\Jump2App;..\..\option;..\..\tempCalibration
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: at32f435_437_int.c at32f435_437_wk_config.c main.c wk_system.c
  group firmware
    ../../libraries/drivers/src/: at32f435_437_acc.c at32f435_437_adc.c at32f435_437_can.c at32f435_437_crc.c at32f435_437_crm.c at32f435_437_dac.c at32f435_437_debug.c at32f435_437_dma.c at32f435_437_dvp.c at32f435_437_edma.c at32f435_437_emac.c at32f435_437_ertc.c at32f435_437_exint.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_misc.c at32f435_437_pwc.c at32f435_437_qspi.c at32f435_437_scfg.c at32f435_437_sdio.c at32f435_437_spi.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_usb.c at32f435_437_wdt.c at32f435_437_wwdt.c at32f435_437_xmc.c
  group cmsis
    ./: startup_at32f435_437.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
  group mylib
    ../../mylib/src/: ATFlash.c ATSpi.c ATUsart.c
  group ASM330LHHX
    ../../ASM330LHHX/src/: asm330lhhx.c
  group calibration
    ../../calibration/src/: errorcor.c
  group adxl375
    ../../adxl375/src/: adxl375.c
  group jump2app
    ../../Jump2App/: jump2app.c
  group option
    ../../option/: option.c
  group tempCalibration
    ../../tempCalibration/: tempCalibration.c
